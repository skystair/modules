# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F10X_MD
  c include: .\_code;.\_code\STM32F1xx_HAL_Driver\Inc;.\_code\CORE;.\_code\bsp;.\_code\device;.\_code\func;.\_code\func\usb_hid;.\_code\func\usb_lib;.\_code\task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group bsp
    ./_code/bsp/: timerx.c
  group device
    ./_code/device/: key.c led.c
  group dev_433
    ./_code/device/: RF_433_MX_STM32F103.c RF_433_MX.c RF_433_MX_RX.c RF_433_MX_TX.c
  group dev_433Uart
    ./_code/device/: RF_433_MX_uart_STM32F103.c RF_433_MX_uart.c
  group func
    ./_code/func/: dlibx.c RF_433_MX_test_rx.c RF_433_MX_test_tx.c
  group task
    ./_code/task/: task_com1.c task_mode.c
  group main
    ./_code/: main.c config.h boardIO.c
software components: CMSIS:CORE 6.2.0, RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
