# Keil uVision project stm32f407IG_demo.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407IG_demo +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER
  c include: .\;.\_code;.\_code\bsp;.\_code\device;.\_code\dev;.\_code\func;.\_code\lib;.\_code\sys;.\_code\ll_lib\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./_code/: main.c
    ./_code/sys/: system_stm32f4xx.c stm32f4xx_it.c startup_stm32f407xx.s
  group RTOS
    ./_code/func/: bldc_func.c bldc_hall.c bldc_drive_6step.c
    ./_code/dev/: keyx.c
    ./_code/lib/: dlibx.c
  group bsp
    ./_code/bsp/: gpiox.c timerx.c
  group LL_Driver
    ./_code/ll_lib/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_tim.c stm32f4xx_ll_pwr.c
software components: CMSIS:CORE 6.2.0
