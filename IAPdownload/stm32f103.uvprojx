# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,STM32F10X_HD
  c include: .\_code;.\_code\sys;.\_code\bsp;.\_code\device;.\_code\device\lcd;.\_code\func;.\_code\task;.\_code\lib;.\_code\usb;.\_code\storage
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bsp
    ./_code/bsp/: timerx.c boarddef.c
  group device
    ./_code/device/: key.c led.c
    ./_code/device/lcd/: lcd.c lcd_display.c
  group func
    ./_code/func/: modefunc.c ui_display.c
  group task
    ./_code/task/: task_com1.c task_mode.c
  group lib
    ./_code/lib/: dlibx.c
  group main
    ./_code/: main.c config.h
  group usb
    ./_code/usb/: usb_cdc.c USBD_STM32F10x.c GPIO_STM32F10x.c
    ./_code/bsp/: uart1_passthrough.c
  group storage
    ./_code/storage/: flash_store.c flash_store.h xmodem.c xmodem.h transfer.c transfer.h
software components: CMSIS Driver:GPIO:Custom 1.0.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.1, CMSIS Driver:USB Device 3.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, USB:CORE 8.0.2, USB:Device:CDC 8.0.2, USB:Device 8.0.2
